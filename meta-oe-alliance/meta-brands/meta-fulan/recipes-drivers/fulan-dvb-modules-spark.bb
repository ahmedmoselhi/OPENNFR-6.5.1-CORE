require fulan-dvb-modules.inc

PR = "${INC_PR}"

SRCDATE = "20191115"

COMPATIBLE_MACHINE = "spark"
